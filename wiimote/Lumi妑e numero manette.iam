# Autodesk Inventor assembly: Lumière numero manette
## iProperties
Created: 2010-07
Part Number: Lumière numero manette
Document SubType Name: Assembly
Designer: eric
Author: eric
