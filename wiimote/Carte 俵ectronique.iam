# Autodesk Inventor assembly: Carte électronique
## iProperties
Created: 2010-07
Part Number: Carte électronique
Document SubType Name: Assembly
Designer: eric
Author: eric
