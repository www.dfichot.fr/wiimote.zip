# Autodesk Inventor assembly: Vibreur
## iProperties
Created: 2010-07
Part Number: Vibreur
Document SubType Name: Assembly
Designer: eric
Author: eric
