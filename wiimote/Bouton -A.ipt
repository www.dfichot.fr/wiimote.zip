# Autodesk Inventor part: Bouton -
## iProperties
Created: 2010-07
Part Number: Bouton -
Document SubType Name: Modeling
Designer: eric
Density: 1 g/cm^3
Author: eric
## Feature names
1. Base1
