# Autodesk Inventor part: Capot piles
## iProperties
Created: 2010-07
Part Number: Capot piles
Document SubType Name: Modeling
Designer: eric
Density: 1 g/cm^3
Author: eric
## Feature names
1. Base1
