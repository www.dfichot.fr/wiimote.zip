# Autodesk Inventor part: Bouton 1
## iProperties
Created: 2010-07
Part Number: Bouton 1
Document SubType Name: Modeling
Designer: eric
Density: 1 g/cm^3
Author: eric
## Feature names
1. Base1
