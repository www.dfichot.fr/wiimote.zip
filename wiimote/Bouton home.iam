# Autodesk Inventor assembly: Bouton home
## iProperties
Created: 2010-07
Part Number: Bouton home
Document SubType Name: Assembly
Designer: eric
Author: eric
