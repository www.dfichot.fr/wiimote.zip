# Autodesk Inventor assembly: Bouton A
## iProperties
Created: 2010-07
Part Number: Bouton A
Document SubType Name: Assembly
Designer: eric
Author: eric
